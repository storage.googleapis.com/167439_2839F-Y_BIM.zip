Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-14T08:27:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.2.0.0 - Alternate UI 16.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 14 08:27:28 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{EFB55749-7BBF-4F94-99B1-0A33A1BC4903}\ifc * Database version: 5507 * Database creation date: Thu Jun 14 08:27:27 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 14 08:27:28 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 14 08:27:28 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcFlowController: 2839F-Y Kitchen faucet with dishwasher valve, 6 V, 2839F-Y:2839F-Y Kitchen faucet with dishwasher valve, 6 V:305727
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 259.5 mm; NominalHeight: 313 mm; NominalWidth: 61.7601 mm
Type - Electrical - Battery: Lithium 2CR5 6 V; Operating Voltage: 6 V
Type - General - Author: Convergo AB; BIMObjectName: 2839F-Y; ConvergoRefNr: 0087-1806-0041-FI; ExpiringDate: 12/2018; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Kitchen faucet with high spout.; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 08/06/2018
Type - Green Building Properties - EAN Number: 6414150071447; EMC Directive: 2004/108/EY; ETA-Danmark: VA 1.42/17876; LVI Number: 6219078; Noise Class: I (ISO 3822); NRF Number: 4200395; Protection Class: IP 55; RSK Number: 8348032; Sintef Certificate: Sintef Nr. 1323; STF Certificate: VTT-RTH-04950-08
Type - Identity Data - Class: Single lever, battery operated; Group: Kitchen faucets; Manufacturer: Oras; Market: FIN;NOR;SWE;RUS;LTU;LVA; Model: 2839F-Y Kitchen faucet with dishwasher valve, 6 V; Name_en: 2839F-Y Kitchen faucet with dishwasher valve, 6 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2839F-Y; Product Datasheet: https://www.oras.com/datasheet/2839F-Y/sv; Product Family: Oras Cubista; Product URL: https://www.oras.com/se/produkter/oras-cubista/product/2839F-Y/; Type Name: 2839F-Y Kitchen faucet with dishwasher valve, 6 V
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Dishwasher Valve: Electronic dishwasher valve; Dishwasher Valve Open Period: 4 h / 12 h; Flow Rate At 300kPa: 0.00706293 m3/s; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 02ls: 300000 Pa; Spout Type: Swivel spout
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2839F-Y; Features: Single lever, battery operated; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2839F-Y; Name: 2839F-Y Kitchen faucet with dishwasher valve, 6 V; ReplacementCost: n/a; Shape: Sculptured; Size: 62x260x313 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2839F-Y; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2839F-Y Kitchen faucet with dishwasher valve, 6 V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 0; Level: Level: Level 0; Offset: 0 mm
Dimensions - Area: 0.117681 m2; Volume: 0.00502108 m3
Identity Data - Mark: 7
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2839F-Y: 2839F-Y Kitchen faucet with dishwasher valve, 6 V; Family and Type: 2839F-Y: 2839F-Y Kitchen faucet with dishwasher valve, 6 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2839F-Y: 2839F-Y Kitchen faucet with dishwasher valve, 6 V; Type Id: 2839F-Y: 2839F-Y Kitchen faucet with dishwasher valve, 6 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
